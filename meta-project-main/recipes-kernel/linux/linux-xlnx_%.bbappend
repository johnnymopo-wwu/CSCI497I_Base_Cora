
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://systemd-support.cfg"
