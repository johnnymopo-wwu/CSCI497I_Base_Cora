FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
EXTRA_DT_INCLUDE_FILES += "system-user.dtsi"
